# Allegro board CN0577 Allegro File.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
AMP_PWR-: length 18.2
  TOP w0.2: U10.15 32.09,44.79 v1(32.05,44.83) ; v1(32.66,44.86) 32.59,44.78 U10.14
  TOP w0.35: P7.2 12.75,3.3
  TOP w0.5: 12.75,3.3 UNK-1V.1 C9.1 15.26,16.92
  vias: v1(17.65,17.27) v1(17.91,17.78) v1(18.29,17.27) v1(31.37,48.39) v1(31.37,47.62) v1(31.75,43.18) v1(31.75,42.67) v1(31.75,42.16) v1(32.26,43.18) v1(32.26,42.67) v1(32.26,42.16) v1(32.77,43.18) v1(32.77,42.67) v1(32.77,42.16) v1(33.4,48.39) v1(33.4,47.62)
BYPASS+: length 22
  TOP w0.2: JP11.1 15.62,47.24 18.16,49.78 35.43,49.78
  TOP w0.203: JP6.3 35.59,49.63 35.43,49.78
BYPASS-: length 21.3
  TOP w0.203: JP7.3 35.59,36.44 34.83,35.68 17.96,35.68 15.67,37.97 JP12.3
C10: length 1.1
  BOTTOM w0.2: P4.C10 v1(94.23,48.34)
C11: length 1.1
  BOTTOM w0.2: P4.C11 v1(94.23,47.06)
C22: length 1.1
  BOTTOM w0.2: 93.17,33.09 v1(94.23,33.09)
C23: length 1.1
  BOTTOM w0.2: P4.C23 v1(94.23,31.82)
CLK+: length 40.5
  TOP w0.254: U1.24 55.23,43.37 R57.1 56.54,43.36 62.64,43.36 70.45,51.18 73.5,51.18 75.28,52.96 88.53,52.96 88.81,53.24 88.81,53.23 v1(88.85,53.23)
  BOTTOM w0.254: v1(88.85,53.23) 88.28,53.23 88.09,53.41
CLK-: length 40.4
  TOP w0.254: v1(88.85,52.31) 88.8,52.31 88.53,52.58 75.44,52.58 73.66,50.8 70.61,50.8 62.79,42.98 56.54,42.98 R57.2 55.33,42.87 U1.23
  BOTTOM w0.254: P4.G7 88.26,52.31 v1(88.85,52.31)
CNV+_EXT: length 1.8
  TOP w0.203: JP9.1 R83.2
CNV_EN: length 35.1
  TOP w0.2: R82.1 89.71,44.7 v1(90.35,45.34) 90.35,58.8 86.76,62.38 TP17.1
  BOTTOM w0.2: v1(90.35,45.34) 90.35,47.88 89.89,48.34 P4.G10
DA+: length 38.2
  TOP w0.254: v1(81.53,51.98) 81.06,51.98 80.78,51.7 79.48,51.7 76.68,48.89 71.3,48.89 62.72,40.31 54.86,40.31 54.8,40.37 U1.18
  BOTTOM w0.254: v1(81.53,51.98) 82.01,51.98 82.29,51.7 86.38,51.7 P4.H7
DA-: length 38.2
  TOP w0.254: U1.17 54.8,39.87 54.86,39.93 62.87,39.93 71.45,48.51 76.83,48.51 79.64,51.32 80.78,51.32 81.06,51.04 v1(81.53,51.04)
  BOTTOM w0.254: P4.H8 86.38,51.32 82.29,51.32 82.01,51.04 v1(81.53,51.04)
DB+: length 39.8
  TOP w0.254: U1.16 53.13,38.2 53.07,38.14 53.07,37.78 53.32,37.53 61.55,37.53 71.91,47.89 85.61,47.89 v1(86.05,48.34)
  BOTTOM w0.254: P4.H10 v1(86.05,48.34)
DB-: length 40.4
  TOP w0.254: v1(86.05,47.06) 85.61,47.51 72.07,47.51 61.71,37.15 53.16,37.15 52.69,37.63 52.69,38.14 52.63,38.2 U1.15
  BOTTOM w0.254: P4.H11 v1(86.05,47.06)
DCO+: length 41
  TOP w0.254: v1(76.05,51.69) 76.05,51.21 76.33,50.94 76.33,50.3 76.07,50.04 70.89,50.04 62.16,41.31 54.86,41.31 54.8,41.37 U1.20
  BOTTOM w0.254: P4.H4 86.38,55.51 78.6,55.51 76.33,53.24 76.33,52.44 76.05,52.16 v1(76.05,51.69)
DCO-: length 41
  TOP w0.254: U1.19 54.8,40.87 54.86,40.93 62.32,40.93 71.04,49.66 76.22,49.66 76.71,50.14 76.71,50.94 76.99,51.21 v1(76.99,51.69)
  BOTTOM w0.254: v1(76.99,51.69) 76.99,52.16 76.71,52.44 76.71,53.08 78.76,55.13 86.38,55.13 P4.H5
DIFF_OUT+: length 16
  TOP w0.2: R72.2 R70.2 C60.2 35.59,45.34 ; U10.11 34.77,42.87
  TOP w0.203: 34.77,42.87 35.59,43.69 35.59,45.34
DIFF_OUT-: length 16
  TOP w0.2: U10.10 34.74,42.37 ; R69.2 R68.2 C58.2 JP7.1
  TOP w0.203: JP7.1 35.59,41.53 34.74,42.37
FPGA_CNV+: length 45.8
  TOP w0.2: v1(51.23,53.47) 51.23,52.28 R56.1 50.74,51.79 JP9.3
  BOTTOM w0.2: P4.D8 91.24,50.21 68.02,50.21 64.77,53.47 v1(51.23,53.47)
FPGA_CNV-: length 44.7
  TOP w0.2: JP10.1 53.09,51.6 R56.2 52.25,52.44 v1(52.25,52.97)
  BOTTOM w0.2: P4.D9 91.3,49 68.52,49 64.55,52.97 v1(52.25,52.97)
FPGA_PD_CONTROL: length 8.3
  TOP w0.2: v1(89.33,41.66) R32.2
  BOTTOM w0.2: P4.G18 88.72,38.17 89.33,38.79 v1(89.33,41.66)
FPGA_TESTPAT_CONTROL: length 50.4
  TOP w0.2: R55.2 61.4,36.2 71.56,46.35 v1(89.84,46.35)
  BOTTOM w0.2: v1(89.84,46.35) 89.84,36.11 P4.G21
FPGA_TWOLANES_CONTROL: length 18.7
  TOP w0.2: R34.2 v1(90.47,43.18)
  BOTTOM w0.2: P4.G24 90.47,32.93 v1(90.47,43.18)
GA0: length 4.2
  TOP w0.2: v1(94.61,19.3) U9.2
  BOTTOM w0.2: P4.C34 93.8,17.86 94.61,18.67 v1(94.61,19.3)
GA1: length 6.4
  TOP w0.2: U9.1 93.34,17.78 v1(93.9,17.23)
  BOTTOM w0.2: v1(93.9,17.23) 92.55,17.23 P4.D35
LVDS_CLK+: length 21.4
  TOP w0.254: v1(88.96,58.49) 88.51,58.04 74.26,58.04 71.64,55.42 71.64,54.95 71.12,54.43 U15.7
  BOTTOM w0.254: v1(88.96,58.49) P4.G2
LVDS_CLK-: length 20.6
  TOP w0.254: v1(88.95,57.22) 88.52,57.66 74.42,57.66 72.02,55.26 72.02,54.9 72.39,54.53 U15.8
  BOTTOM w0.254: v1(88.95,57.22) P4.G3
OVDD: length 1.2
  TOP w0.2: U1.22 54.57,42.37 v1(54.86,42.08)
  vias: v1(63.75,17.65) v1(63.75,17.02) v1(63.75,16.38)
REFBUF: length 12.4
  TOP w0.5: v1(37.9,36.11) 43.35,36.11 45.57,38.32 C46.1
  BOTTOM w0.5: R74.2 v1(37.9,36.11)
REFIN_OVERDRIVE: length 3.5
  TOP w0.35: P5.2 47.9,34.29
  TOP w0.5: C44.1 49.11,35.5 47.9,34.29
SCL: length 5.8
  TOP w0.2: v1(95.88,24.61) 95.88,26.16
  BOTTOM w0.2: v1(95.88,24.61) 95.88,23.14 95.69,22.94 93.17,22.94
SDA: length 8.1
  TOP w0.2: U9.5 v1(97.16,24.61)
  BOTTOM w0.2: v1(97.16,24.61) 97.16,22.3 96.52,21.67 P4.C31
UNNAMED_3_ADA48071_I32_: length 3.4
  TOP w0.2: A1.4 57.68,28.97 C7.1 59.46,29.33 R8.1
UNNAMED_3_ADA48071_I32__2: length 3.3
  TOP w0.2: R6.1 R4.2 A1.3
UNNAMED_3_ADA48071_I32_DISABLEN: length 1.6
  TOP w0.2: R5.1 A1.5
UNNAMED_3_ADA48071_I32_VOUT: length 9.4
  TOP w0.2: R8.2 C7.2 54.78,27.73 54.41,27.37 A1.1 C8.1 R9.1
UNNAMED_3_ADR45XX_I16_VIN: length 5.3
  TOP w0.5: R1.2 34.67,29.68 C1.2 C2.1 U2.2
UNNAMED_3_ADR45XX_I16_VOUT: length 4.4
  TOP w0.5: R3.1 C5.1 U2.6
UNNAMED_3_NC2P_I68_N1: length 2.5
  TOP w0.35: 46.23,33.54 P5.1
  TOP w0.5: R3.2 46.23,33.54
UNNAMED_7_ADLT3080_I683_OUT1:
  vias: v1(74.93,20.32) v1(74.93,19.56) v1(75.69,24.38) v1(75.69,23.62) v1(75.69,22.73) v1(75.69,21.84) v1(75.69,21.08) v1(75.69,20.32) v1(75.69,19.56) v1(76.45,21.08) v1(76.45,20.32) v1(76.45,19.56) v1(76.58,23.62) v1(76.58,22.73) v1(77.22,23.62) v1(77.22,22.73) v1(77.22,21.08) v1(77.22,20.32) v1(77.22,19.56) v1(77.85,23.62) v1(77.85,22.73)
UNNAMED_7_CAP_I582_N1: length 4.2
  TOP w0.203: U5.7 C23.1 R23.1
UNNAMED_7_CAP_I616_N1: length 4.3
  TOP w0.203: U6.7 57.47,13.61 57.47,13.61 C24.1 R24.2
UNNAMED_7_CAP_I630_N1: length 4.2
  TOP w0.254: R25.2 C25.1 U7.7
UNNAMED_7_CAP_I647_N1: length 4.2
  TOP w0.2: R26.2 C26.1 7.21,10.34
  TOP w0.203: 7.21,10.34 U8.8
UNNAMED_7_CAP_I648_N1: length 1.1
  TOP w0.2: U8.10 8.11,11.14 8.38,10.87 8.73,10.87
UNNAMED_7_CAP_I731_N1: length 4.1
  TOP w0.203: R85.1 C67.1 U14.7
UNNAMED_7_CAP_I738_N1: length 18.6
  TOP w0.35: P8.2 43.55,3.3
  TOP w0.5: 43.55,3.3 UNK3.3V.1 C3.1 E4.1 E5.1
UNNAMED_7_CNTP1P_I534_N1: length 4.3
  TOP w0.508: JP2.3 EXTPWR.1
UNNAMED_7_FERRITE_I431_N1: length 2
  TOP w0.508: JP2.2 E1.1
UNNAMED_7_LINLT3042_I575_EN: length 3.2
  TOP w0.203: U5.3 R15.1 R16.2
UNNAMED_7_LINLT3042_I575_ILIM: length 1.7
  TOP w0.203: R27.2 U5.5
UNNAMED_7_LINLT3042_I610_EN: length 3.4
  TOP w0.203: R18.2 R17.1 U6.3
UNNAMED_7_LINLT3042_I610_ILIM: length 1.8
  TOP w0.203: R28.2 57.96,7.34 U6.5
UNNAMED_7_LINLT3042_I626_EN: length 3.3
  TOP w0.2: R20.1 R19.1 U7.3
UNNAMED_7_LINLT3042_I626_ILIM: length 2
  TOP w0.2: R30.2 69.11,6.88 68.48,7.51 U7.5
UNNAMED_7_LINLT3042_I726_EN: length 3.3
  TOP w0.203: R84.2 R2.1 U14.3
UNNAMED_7_LINLT3042_I726_ILIM: length 1.7
  TOP w0.203: R86.2 U14.5
UNNAMED_7_LINLT3094_I642_EN: length 3.1
  TOP w0.2: R21.1 8.11,16.2
  TOP w0.203: 8.11,16.2 R22.2 ; U8.3 R21.1
UNNAMED_7_LINLT3094_I642_ILIM: length 1.6
  TOP w0.2: R29.2 U8.6
UNNAMED_8_ADLTC238718_I172_CNV: length 4.6
  TOP w0.2: JP10.2 53.09,47.26 52.13,46.3 U1.27
UNNAMED_8_ADLTC238718_I172_CNV_1: length 4.6
  TOP w0.2: JP9.2 50.74,47.26 51.63,46.37 U1.28
UNNAMED_8_ADLTC238718_I172_IN: length 13.1
  TOP w0.2: R53.2 C42.1 41.01,45.33 41.21,45.13 TP11.1 42.19,43.47 C41.1
  TOP w0.203: U1.2 45.02,42.87 44.43,43.47 C41.1
UNNAMED_8_ADLTC238718_I172_IN_1: length 13.1
  TOP w0.2: R54.2 C43.1 41.08,39.88 41.21,40.02 TP12.1 42.32,41.87 C41.2
  TOP w0.203: C41.2 44.43,41.87 44.93,42.37 U1.3
UNNAMED_8_ADLTC238718_I172_PDN: length 44.5
  TOP w0.2: U1.13 51.63,37.15 54.23,34.54 58.8,34.54 61.59,31.75 P1.2 65.07,31.75 66.04,32.72 66.04,39.75 67.94,41.66 R32.1
UNNAMED_8_ADLTC238718_I172_TESTPAT: length 15.6
  TOP w0.2: P2.2 63.45,36.32 62.31,35.18 54.87,35.18 54.65,35.4 R55.1 53.21,36.2 52.13,37.28 U1.14
UNNAMED_8_ADLTC238718_I172_TWOLANES: length 33.8
  TOP w0.2: R34.1 v1(82.8,43.18) ; U1.25 53.13,44.37 56.17,47.41 P3.2
  BOTTOM w0.2: v1(82.8,43.18) 71.55,43.18 67.32,47.41 P3.2
UNNAMED_8_NC3PJMPR_I256_COM: length 1.7
  TOP w0.2: R53.1 JP6.2
UNNAMED_8_NC3PJMPR_I257_COM: length 1.7
  TOP w0.2: JP7.2 R54.1
UNNAMED_10_CN160PCDGHV2_I85_TDI: length 1.3
  BOTTOM w0.2: 91.91,22.94 P4.D31
UNNAMED_11_ADA49451_I55_: length 9.4
  TOP w0.2: R63.2 R69.1 R68.1 25.43,41.58 25.53,41.48 C58.1 27.18,41.48 28.07,42.37 U10.3
UNNAMED_11_ADA49451_I55__1: length 9.4
  TOP w0.2: U10.2 27.99,42.87 27.12,43.74 C60.1 25.53,43.74 25.43,43.64 R70.1 R72.1 R62.2
UNNAMED_11_ADA49451_I55__2: length 4.5
  TOP w0.2: v1(34.29,40.51) 33.45,40.51 33.09,40.88 U10.8
  BOTTOM w0.2: R74.1 R71.2 34.76,40.04 v1(34.29,40.51)
UNNAMED_11_ADA49451_I55__3: length 4.4
  TOP w0.2: U10.13 33.09,44.47 33.32,44.7 v1(34.19,44.7)
  BOTTOM w0.2: v1(34.19,44.7) 34.76,45.27 R73.2 R75.1
UNNAMED_11_ADA49451_I55_DGND: length 4.3
  TOP w0.2: v1(30.48,44.7) 31.29,44.7 31.59,44.41 U10.16
  BOTTOM w0.2: v1(30.48,44.7) 30.01,45.17 R67.2 R65.2
UNNAMED_11_ADA49451_I55_DISABLEN: length 2
  TOP w0.2: U10.12 34.2,43.37 v1(34.67,43.84)
  BOTTOM w0.2: R76.2 v1(34.67,43.84)
UNNAMED_11_ADA49451_I55_MODE: length 4.4
  TOP w0.2: U10.5 31.59,40.81 31.29,40.51 v1(30.48,40.51)
  BOTTOM w0.2: v1(30.48,40.51) 30.01,40.04 R66.2 R64.2
UNNAMED_11_CAP_I59_N1: length 6.4
  TOP w0.2: C56.1 R60.2 ; R60.2 JP11.3 ; R60.2 R62.1
UNNAMED_11_CAP_I59_N2: length 6.1
  TOP w0.2: JP12.1 R61.1 ; R61.1 R63.1 ; R61.1 C56.2
UNNAMED_11_CNBNC5P_I184_CNTR: length 14.4
  TOP w0.203: J1.1 TP14.1 R59.2
UNNAMED_11_CNBNC5P_I186_CNTR: length 14.6
  TOP w0.203: R58.2 TP15.1 J2.1
UNNAMED_11_NC3PJMPR_I180_COM: length 3.7
  TOP w0.2: R59.1 JP11.2
UNNAMED_11_NC3PJMPR_I181_COM: length 3.8
  TOP w0.2: R58.1 JP12.2
UNNAMED_12_741G04V2_I168_Y: length 1.8
  TOP w0.2: JP14.3 U12.4
UNNAMED_12_741G74V3_I179_CLK: length 1.8
  TOP w0.2: 54.6,53.65 R80.2 ; U13.1 54.27,53.65
  TOP w0.203: 54.27,53.65 54.6,53.65
UNNAMED_12_741G74V3_I179_CLRN: length 41.6
  TOP w0.2: v1(48.13,54.99) 48.18,54.95 U13.6 ; v1(82.8,44.7) R82.2
  BOTTOM w0.2: v1(48.13,54.99) 50.67,52.45 64.44,52.45 72.19,44.7 v1(82.8,44.7)
UNNAMED_12_741G74V3_I179_Q: length 8.3
  TOP w0.203: U13.5 47.6,55.6 46.99,54.99 R83.1
UNNAMED_12_ADG3241_I155_A: length 17.5
  TOP w0.203: U15.2 TP16.1 JP14.2 U11.3
UNNAMED_12_ADG3241_I155_B: length 7.5
  TOP w0.2: R80.1 63.34,53.65 64.14,52.85 U11.4
UNNAMED_12_ADG3241_I155_SELN: length 5.4
  TOP w0.2: R37.1 61.6,49.96 61.9,49.66 64.19,49.66 64.83,50.3 U11.6
UNNAMED_12_CAP_I66_N1: length 1.5
  TOP w0.2: C64.1 R77.2
UNNAMED_12_CAP_I66_N2: length 4.5
  TOP w0.2: C64.2 R79.2 R78.1 U12.2
UNNAMED_12_CNBNC5P_I167_CNTR: length 4.8
  TOP w0.2: J3.1 R77.1
UNNAMED_12_NC3PJMPR_I170_A: length 24
  TOP w0.203: Y1.3 60.07,57.73 63.81,61.47 63.96,61.47 64.82,62.33 JP14.1
UNNAMED_12_RES_I161_N1: length 4.5
  TOP w0.203: Y1.1 R45.1 R46.2
VCM: length 4.7
  TOP w0.2: v1(50.14,23.14) R7.2 R9.2 ; U10.9 34.2,41.87 v1(34.67,41.4)
  BOTTOM w0.2: C61.1 v1(34.67,41.4)
VCM_OUT: length 17
  TOP w0.2: v1(48.11,46.99) 48.43,46.67 C45.1 ; R4.1 56.31,22.02 55.75,21.46 49.91,21.46 49.28,22.1 49.28,24.03 v1(50.09,24.84) R7.1
  TOP w0.203: U1.32 49.63,45.45 49.2,45.87 C45.1

## Copper pours and planes (outline as drawn)
+2.5V on TOP: 50.6,53.34 50.6,53.85 47.55,53.85 47.55,51.69 47.67,51.56 48.95,51.56 49.07,51.69 49.07,52.96 49.45,53.34
+2.5V on L3_PWR: 46.32,52.12 46.32,56.34 67.75,56.32 67.75,25.59 64.64,25.59 64.42,25.5 64.33,25.27 64.33,17.59 61.15,17.59 61.15,29.02 64.39,29.02 64.61,29.11 64.71,29.34 64.67,51.81 64.58,52.03 64.36,52.12
+3.3V on TOP: 72.14,57.66 72.69,57.66 72.95,57.91 72.95,58.67 73.33,59.05 74.73,59.05 75.06,59.39 75.06,65.15 74.55,65.66 73.66,65.66 73.15,65.15 73.15,60.45 72.77,60.07 72.14,60.07 72.01,59.94 72.01,57.78
+3.3V on BOTTOM: 40.34,68.73 78.46,68.73 78.74,68.45 78.74,60.96 78.49,60.71 69.09,60.71 68.83,60.96 68.83,62.86 68.58,63.12 44.2,63.12 42.67,61.72 42.67,6.86 42.29,6.48 40.77,6.48 40.39,6.86 40.39,68.68
+3.3V_CRYSTAL on TOP: 45.09,16.13 46.74,16.13 46.74,17.4 46.61,17.53 45.21,17.53 45.09,17.4
+3.3V_CRYSTAL on BOTTOM: 48.39,60.2 48.01,59.82 46.23,59.82 45.85,59.44 45.85,20.19 46.99,19.05 46.99,16.38 46.74,16.13 44.83,16.13 44.58,16.38 44.58,17.53 44.2,17.91 43.31,17.91 43.05,18.16 43.05,19.3 42.93,60.32 42.93,61.54 44.25,62.86 48.06,62.86 48.39,62.53
+3.3V_TRANSLATOR on TOP: 47.88,16.13 49.53,16.13 49.53,17.4 49.4,17.53 48.01,17.53 47.88,17.4
+3.3V_TRANSLATOR on BOTTOM: 47.62,16 49.53,16 49.78,16.26 49.78,20.32 49.02,21.08 49.02,48.01 50.55,49.53 64.57,49.53 64.95,49.91 64.95,51.69 64.31,52.32 48.64,52.32 46.35,50.04 46.35,20.32 47.37,19.3 47.37,16.26
+6.8V on TOP: 52.58,31.62 52.96,31.62 53.21,31.37 53.21,29.21 53.97,28.45 54.74,28.45 54.86,28.57 54.86,29.34 54.23,29.97 54.23,32.77 54.1,32.89 52.58,32.89 52.45,32.77 52.45,31.75
+6.8V on BOTTOM: 51.56,33.15 53.21,33.15 54.23,32.13 54.23,1.27 52.59,1.27 22.15,1.27 22.15,5.01 25.02,7.87 32.13,7.87 32.64,8.38 32.64,27.26 33.07,27.69 36.75,27.69 37.08,27.36 37.08,8.25 39.24,6.1 42.93,6.1 44.58,7.75 50.04,7.75 50.55,8.25 50.55,32.13
+7.5V on TOP: 55.5,8.83 56.52,8.83 56.64,8.7 56.64,8.19 55.75,7.3 55.75,6.29 55.63,6.16 52.69,6.16 52.5,6.35 52.5,8 52.75,8.25 55.31,8.25 55.37,8.32 55.37,8.7
+7.5V on TOP: 25.26,15.04 24.25,15.04 24.12,15.16 24.12,15.67 25.01,16.56 25.01,17.58 25.14,17.7 28.07,17.7 28.26,17.51 28.26,15.86 28.01,15.61 25.45,15.61 25.39,15.54 25.39,15.16
+7.5V on TOP: 40.05,14.86 39.55,14.86 39.47,14.94 39.47,15.72 40.36,16.61 40.36,17.63 40.49,17.75 43.42,17.75 43.61,17.56 43.61,15.91 43.36,15.66 40.85,15.66
+7.5V on TOP: 65.91,8.83 66.93,8.83 67.06,8.7 67.06,8.19 66.17,7.3 66.17,6.29 66.04,6.16 63.11,6.16 62.91,6.35 62.91,8 63.17,8.25 65.72,8.25 65.79,8.32 65.79,8.7
+7.5V on L3_PWR: 68.52,21.65 71.74,21.65 71.74,6.08 26.78,6.08 26.78,16.19 29.58,16.19 29.58,12.57 29.67,12.35 29.89,12.26 41.2,12.26 41.42,12.35 41.52,12.57 41.52,16.32 43.55,16.32 43.55,12.57 43.64,12.35 43.86,12.26 68.2,12.26 68.42,12.35 68.52,12.57
+12V on TOP: 80.01,27.05 80.01,24.51 79.76,24.26 78.11,24.26 77.98,24.38 77.98,25.02 77.85,25.15 77.34,25.15 77.22,25.02 77.22,24.38 77.09,24.26 76.45,24.26 76.33,24.38 76.33,26.04 76.71,26.42 78.74,26.42 78.99,26.67 78.99,27.05 79.12,27.18 79.88,27.18
+12V on TOP: 71.37,38.99 73.02,38.99 73.15,39.12 73.15,41.27 73.02,41.4 71.37,41.4 71.25,41.27 71.25,39.12
+12V on TOP: 82.68,32.77 83.82,32.77 83.95,32.89 83.95,36.07 84.07,36.2 84.71,36.2 84.84,36.32 84.84,37.21 84.71,37.34 82.68,37.34 82.55,37.21 82.55,32.89
+12V on TOP: 73.02,12.57 75.06,12.57 75.18,12.45 81.15,12.45 81.41,12.7 81.41,13.72 81.15,13.97 73.02,13.97 72.9,13.84 72.9,12.7
+12V on L3_PWR: 71.44,41.72 84.77,41.72 84.77,36 81.66,36 81.44,35.91 81.34,35.69 81.34,12 79.06,12 79.06,26.04 78.96,26.26 78.74,26.35 72.38,26.35 72.38,35.56 72.28,35.78 72.06,35.88 71.44,35.88
-3V on TOP: 6.69,12.15 9.07,12.15 9.07,14.32 10.24,15.49 13.13,15.49 13.26,15.62 13.26,17.4 10.97,17.4 10.97,16.89 10.72,16.64 9.32,16.64 8.81,16.13 8.81,15.11 8.43,14.73 8.43,14.22 8.01,13.8 6.69,13.8
-3V on BOTTOM: 6.6,13.84 9.14,13.84 9.4,13.59 9.4,12.32 9.14,12.07 6.6,12.07 6.35,12.32 6.35,13.59
-3V on L3_PWR: 68.39,31.56 71.74,31.56 71.74,22.29 68.2,22.29 67.97,22.2 67.88,21.97 67.88,12.89 44.18,12.89 44.18,16.64 44.09,16.86 43.86,16.95 41.2,16.95 40.97,16.86 40.88,16.64 40.88,12.89 30.21,12.89 30.21,16.51 30.12,16.73 29.89,16.83 26.47,16.83 26.24,16.73 26.15,16.51 26.15,9.59 6.37,9.59 6.37,17.34 14.03,17.34 14.03,16.51 14.13,16.29 14.35,16.19 19.05,16.19 19.27,16.29 19.37,16.51 19.37,20.79 27.87,20.77 27.9,20.77 27.94,20.76 27.98,20.77 28.01,20.77 32.5,20.77 32.5,16.51 32.59,16.29 32.82,16.19 35.48,16.19 35.71,16.29 35.8,16.51 35.8,20.89 51.5,20.89 51.5,17.27 51.59,17.05 51.82,16.95 64.64,16.95 64.87,17.05 64.96,17.27 64.96,24.96 68.07,24.96 68.3,25.05 68.39,25.27
AGND on TOP: 90.22,68.73 98.73,68.73 98.73,1.27 90.22,1.27 90.22,3.51 88.7,3.51 88.7,3.51 85.78,3.51 85.78,1.27 6.03,1.27 6.03,3.56 2.59,3.56 2.59,1.27 1.27,1.27 1.27,4.7 3.59,4.7 3.59,6.03 1.27,6.03 1.27,63.95 3.54,63.95 3.54,68.73 3.56,68.73 3.56,66.42 6.02,66.42 6.03,66.42 6.03,68.73 85.78,68.73 85.78,66.51 87.81,66.51 90.22,66.51 ; 13 cut-outs
AGND on BOTTOM: 98.73,1.27 1.27,1.27 1.27,68.73 98.73,68.73 ; 9 cut-outs
AGND on L2_GND: 98.73,68.73 98.73,1.27 1.27,1.27 1.27,68.73 ; 2 cut-outs
AGND on L3_PWR: 1.27,68.73 98.73,68.73 98.73,1.27 1.27,1.27 1.27,31.12 0,31.12 0,38.73 1.27,38.73 1.27,46.23 0,46.23 0,53.72 1.27,53.72 ; 3 cut-outs
VDD on BOTTOM: 51.74,33.53 53.39,33.53 53.59,33.73 53.59,37.01 53.14,37.46 53.14,38.61 52.88,38.86 50.93,38.86 50.72,38.66 50.72,37.72 51.48,36.96 51.48,33.78
VDD on L3_PWR: 52.13,39.05 55.82,39.05 55.82,17.59 52.13,17.59 52.13,26.9 52.16,26.98 52.17,27.06 52.16,27.14 52.13,27.21
VDDL on TOP: 49.96,43.69 50.72,43.69 50.72,45.72 50.6,45.85 50.09,45.85 49.96,45.72
VDDL on TOP: 64.52,15.43 65.28,15.43 65.28,17.78 65.15,17.91 64.64,17.91 64.52,17.78
VDDL on BOTTOM: 64.64,15.49 67.99,15.49 68.12,15.62 68.12,45.72 67.23,46.61 53.59,46.61 53.34,46.35 49.58,46.35 49.45,46.23 49.45,44.45 49.58,44.32 50.6,44.32 50.67,44.4 50.67,44.96 50.8,45.09 65.45,45.09 66.22,44.32 66.22,18.03 66.09,17.91 64.64,17.91 64.52,17.78 64.52,15.62
AMP_PWR+ on TOP: 34.04,16.38 34.42,16.76 34.42,17.65 34.04,18.03 30.53,18.03 30.15,17.65 30.15,16.64 30.4,16.38
AMP_PWR+ on BOTTOM: 32.89,37.97 32.89,38.48 33.15,38.73 33.4,38.73 33.53,38.86 33.53,40.51 33.4,40.64 31.37,40.64 31.24,40.51 31.24,38.86 31.37,38.73 31.62,38.73 31.88,38.48 31.88,37.97 31.75,37.85 31.24,37.85 31.12,37.72 31.12,36.58 31.24,36.45 33.53,36.45 33.66,36.58 33.66,37.72 33.53,37.85 33.02,37.85
AMP_PWR+ on L3_PWR: 28.26,46.8 38.29,46.8 38.29,42.62 31.11,42.62 30.88,42.53 30.79,42.31 30.79,39.26 30.81,39.13 30.88,39.03 30.89,39.02 31,38.95 31.12,38.93 35.17,38.93 35.17,16.83 33.13,16.83 33.13,21.08 33.04,21.31 32.82,21.4 28.26,21.41
AMP_PWR- on TOP: 18.34,16.38 18.72,16.76 18.72,17.65 18.34,18.03 15.04,18.03 14.66,17.65 14.66,16.76 15.04,16.38
AMP_PWR- on BOTTOM: 31.88,47.12 31.88,46.61 31.62,46.35 31.37,46.35 31.24,46.23 31.24,43.38 31.17,43.31 30.28,43.31 30.15,43.18 30.15,41.91 30.28,41.78 33.32,41.78 33.53,41.99 33.53,44.53 33.58,44.58 33.53,44.58 33.53,46.23 33.4,46.35 33.15,46.35 32.89,46.61 32.89,47.12 33.02,47.24 33.53,47.24 33.66,47.37 33.66,48.51 33.53,48.64 31.24,48.64 31.12,48.51 31.12,47.37 31.24,47.24 31.75,47.24
AMP_PWR- on L3_PWR: 24.96,24.69 25.18,24.78 25.27,25.01 25.27,49.09 33.85,49.09 33.85,47.43 27.94,47.43 27.72,47.34 27.62,47.12 27.62,21.41 19.06,21.42 18.83,21.33 18.74,21.11 18.73,16.83 14.67,16.83 14.67,17.71 14.67,24.69
OVDD on TOP: 63.37,15.43 64.14,15.43 64.14,17.78 64.01,17.91 63.5,17.91 63.37,17.78
OVDD on BOTTOM: 62.23,15.49 64.01,15.49 64.14,15.62 64.14,17.91 64.39,18.16 65.84,18.16 65.96,18.29 65.96,41.4 64.95,42.42 54.74,42.42 54.48,42.16 54.48,41.27 54.74,41.02 61.52,41.02 62.1,40.44 62.1,15.62
REFBUF on TOP: 48.31,39.37 48.18,39.24 44.88,39.24 44.88,37.59 48.69,37.59 49.07,37.97 49.07,40.51 48.31,40.51
REFIN_OVERDRIVE on TOP: 49.71,39.5 49.71,36.07 49.58,35.94 48.56,35.94 48.56,37.08 49.2,37.08 49.33,37.21 49.33,39.5
UNNAMED_7_ADLT3080_I683_OUT1 on TOP: 78.49,24 78.61,23.88 78.61,22.48 78.49,22.35 77.85,22.35 77.72,22.23 77.72,19.43 77.6,19.3 73.41,19.3 73.28,19.43 73.28,22.35 73.41,22.48 75.06,22.48 75.31,22.73 75.31,24.51 75.44,24.64 75.82,24.64 75.95,24.51 75.95,24.13 76.07,24
UNNAMED_7_ADLT3080_I683_OUT1 on BOTTOM: 71.63,28.83 70.99,28.19 70.99,17.78 71.63,17.14 81.28,17.14 81.91,17.78 81.91,28.19 81.28,28.83
UNNAMED_7_ADLT3080_I683_OUT1 on L2_GND: 73.41,19.69 73.41,24.89 73.79,25.27 78.61,25.27 78.87,25.02 78.87,19.69 78.49,19.3 73.79,19.3
UNNAMED_7_ADLT3080_I683_SET on TOP: 77.98,22.1 77.98,21.46 78.11,21.34 78.74,21.34 78.87,21.21 78.87,17.53 78.99,17.4 80.01,17.4 80.14,17.53 80.14,22.1 80.01,22.23 78.11,22.23
UNNAMED_7_CAP_I577_N1 on TOP: 24.13,10.54 25.91,10.54 26.92,9.53 26.92,8.89 27.05,8.76 27.81,8.76 27.94,8.89 27.94,9.53 28.83,10.41 28.83,11.81 28.7,11.94 24.13,11.94 24,11.81 24,10.67
UNNAMED_7_CAP_I609_N1 on TOP: 56.52,11.87 51.82,11.87 51.69,12 51.69,14.16 52.58,15.05 53.72,15.05 54.48,14.29 54.48,13.65 54.74,13.4 56.52,13.4 56.64,13.27 56.64,12
UNNAMED_7_CAP_I625_N1 on TOP: 65.41,13.34 67.06,13.34 67.18,13.21 67.18,12.32 67.06,12.19 65.28,12.19 65.15,12.07 62.36,12.07 62.23,12.19 62.23,13.97 61.85,14.35 61.85,15.11 61.98,15.24 65.15,15.24 65.28,15.11 65.28,13.46
UNNAMED_7_CAP_I648_N1 on TOP: 8.43,11.81 13.51,11.81 13.51,9.02 13.39,8.89 11.1,8.89 10.97,9.02 10.97,9.53 9.83,10.67 8.56,10.67 8.43,10.79
UNNAMED_7_CAP_I701_N1 on TOP: 74.68,38.48 79.88,38.48 80.01,38.35 80.01,34.8 80.14,34.67 81.53,34.67 81.66,34.8 81.66,40.77 81.41,41.02 74.68,41.02 74.42,40.77 74.42,38.73
UNNAMED_7_CAP_I701_N2 on TOP: 74.68,35.69 76.96,35.69 77.34,35.31 77.34,33.53 77.47,33.4 79.12,33.4 79.25,33.53 79.25,37.46 79.12,37.59 74.68,37.59 74.55,37.46 74.55,35.81
UNNAMED_7_CAP_I708_N1 on TOP: 71.37,37.59 73.15,37.59 73.28,37.46 73.28,32.64 73.91,32 79.5,32 79.5,30.35 71.75,30.35 71.25,30.86 71.25,37.46
UNNAMED_7_CAP_I725_N1 on TOP: 39.5,10.29 41.27,10.29 42.29,9.27 42.29,8.64 42.42,8.51 43.18,8.51 43.31,8.64 43.31,9.27 44.2,10.16 44.2,11.56 44.07,11.68 39.5,11.68 39.37,11.56 39.37,10.41
UNNAMED_7_LINLT1931_I684_NFB on TOP: 80.14,28.32 81.41,28.32 81.53,28.45 81.53,33.27 81.41,33.4 80.14,33.4 80.01,33.27 80.01,28.45
VCM on L3_PWR: 38.66,41.98 38.7,41.99 41.49,41.99 41.49,24.21 41.58,23.98 41.81,23.89 51.5,23.89 51.5,21.53 35.8,21.53 35.8,39.24 35.71,39.47 35.48,39.56 31.42,39.56 31.42,41.99 38.51,41.99 38.56,41.98 38.61,41.97
VCM_OUT on L3_PWR: 47.31,48.32 48.83,48.32 48.89,27.06 48.98,26.83 49.21,26.74 51.5,26.74 51.5,24.52 47.27,24.52

## Text on the board
Ref Des/Assembly Bottom: 40 | 20 | 1 | 10
User.Comments: 10.    SMOOTHEN EDGES AND FREE FROM BURRS AFTER DEPANELIZATION PROCESS. | 9.    BOARDS TO BE SHIPPED SINGULATED AFTER ASSEMBLY PROCESS. | JP10, JP11 | 8.    INSTALL JUMPER SHUNT (M50-2020005) ON PIN 1 & 2 FOR THE FOLLOWING: | 6.    SHORT JUMPER PINS 2 & 3 BY ADDING SOLDER BLOB WITH THE FOLLOWING REF DES: | DIRECTIVE 2002/95/EC). | JP6, JP7 | 7.    P5, P6, P7, P8 SHOULD BE SHORTED BY DEFAULT BY ADDING SOLDER BLOB. | WITH LEAD-FREE AND RoHS PCB ASSEMBLY STANDARDS (EU RoHS | JP2, JP9, JP12, JP14 | 4.    RoHS COMPLIANCE: ASSEMBLY VENDOR SHOULD ASSURE COMPLIANCE | 5.    SHORT JUMPER PINS 1 & 2 BY ADDING SOLDER BLOB WITH THE FOLLOWING REF DES: | INSTALL JUMPER SHUNT (M50-2020005) ON PIN 2 & 3 FOR THE FOLLOWING: | P2 | P1 , P3
Ref Des/Assembly Top: 1 | 2 | 3 | C | A
Ref Des/Silkscreen Top: EVAL-CN0577-FMCZ | C | A
XSECTION_CHART: *  SURFACE | L1 TOP CONDUCTOR | *  DIELECTRIC | L2 L2_GND PLANE | L3 L3_PWR PLANE | L4 BOTTOM CONDUCTOR | DESIGN CROSS SECTION CHART | ___________________________ | TOTAL THICKNESS 1.6 MM | 1-4
PAGE_OUTLINE: TEST PROCESS | A. GIRON | E. DELOS REYES | H. DE CHAVEZ | M. VALE | K. JABATAN | 07OCT21 | 05AUG22 | LABEL PLACEMENT INFORMATION | HALF SIZE LABELS ARE | AVAILABLE IN THE LIBRARY | PLACE WHEELIE BIN LOGO | TO SUIT THE LAYOUT. | PLACE ROHS COMPLIANT LOGO | TO SUIT THE LAYOUT OR | DELETE IF NOT REQ'D. | PLACE CHINA ROHS COMPLIANT | LOGO TO SUIT THE LAYOUT OR | B | CHANGES AS PER ECR-108492 | R. EUSTACIO | 1.THE BOARD SIZE CAN BE ADJUSTED TO SUIT THE APPLICATION. | 2.THE MOUNTING HOLES CAN BE MOVED/REMOVED TO SUIT THE APPLICATION. | 3.THE FIDUCIALS CAN BE MOVED TO SUIT THE APPLICATION. | 4.ADJUST THE DIMENSIONS TO SUIT THE APPLICATION. | 5.ADD THE CORRECT LAYER STACKUP ON FAB2 BASED ON THE NO OF LAYERS ON THE PCB. | 6.THE ROHS COMPLIANT AND WHEELIE BIN LOGO'S CAN BE MOVED TO THE DESIRED LOCATION. | HALF SIZE VERSIONS OF THE LABELS ARE AVAILABLE IN THE LIBRARY. | NOTES FOR TEMPLATE USAGE. | CUSTOMER EVALUATION Z
DIMENSION: - | " " | (REF) | DIA MAX/NOTE15 | +0.0508MM / -0MM
User.15: ROHS COMPLIANCE NOTE:  HOMOGENOUS MATERIALS IN THIS BOARD SHALL BE COMPLIANT | THE EU RoHS DIRECTIVE 2002/95/EC | 16.    BOARDS TO BE SHIPPED IN ARRAYS AND KEEP INTACT. | PANEL TO BE SUBJECTED TO CUSTOMER'S APPROVAL. | PANELED SOLDER PASTE STENCIL SHOULD BE SENT TO THE CUSTOMER. | 15.    VIAS TO BE FILL WITH NON-CONDUCTIVE EPOXY AND PLATED OVER. | FR4 | FR4 .689MM | NOTE: ALL IMPEDANCE TOLERANCE +/-10% | LAYER | L1 | L4 | DP = DIFFERENTIAL PAIR | 100 OHMS DP | IMPEDANCE | REFERENCE | L2 | L3 | LINE WIDTH | 0.254MM | 0.127MM | SPACE | IMPEDANCE TABLE
User.17: L2 GND | 08-      -07
User.18: L3 PWR | 08-      -08
User.23: B1 | CHANGES AS PER ECR-111981 | 05DEC22 | R. EUSTACIO
User.45: SEE DETAIL B | SEE DETAIL A (AT 5 PLACES) | FIGURE | SIZE | 0.254 | 0.762 | 1.016 | 1.524 | 1.6002 | 1.651 | 2.54 | 1.27 | 2.667 | 3.175 | PLATED | NON-PLATED | DRILL CHART: TOP to BOTTOM | ALL UNITS ARE IN MILLIMETERS | QTY | 717 | 9 | 14 | 1 | 4 | 5 | 2 | TOLERANCE/NOTES | DETAIL B | MM | B
